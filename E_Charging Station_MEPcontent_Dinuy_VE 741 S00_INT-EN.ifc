Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
File name: Project Number
Time: 2026-06-23T15:19:48+02:00
Written by: ODA SDAI 22.12
Made in: 23.0.11.19 - Exporter 23.0.11.19 - Default UI

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; S4R_Use_nominal_diameter: yes; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Floor Level, F00
LongName: F00; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Floor Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: F00; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Other(Type) - Category: Levels; Family Name: Level

# IfcBuildingElementProxy: E_Charging Station_MEPcontent_Dinuy_VE 741 S00_INT-EN:VE 741 S00, E_Charging Station_MEPcontent_Dinuy_VE 741 S00_INT-EN:VE 741 S00:1556440
In: F00
Type - Material: Color RAL 9005, Color RGB 000-071-133, Color RGB 001-254-252, Color RGB 020-020-022, Color RGB 022-050-121, Color RGB 162-162-162
Type - Constraints - Default Elevation: 0 mm
Type - Data - Charging Mode: 3 mode; Conectivity: RFID, Bluetooth 5, Wi-Fi 2,4 GHz, Ethernet, OCPP 1.6, KNX; Environmental Protection: IP54; Frequency: 50/60 Hz; Impact Protection: IK10; Maximum Operating Temperature: 50 C; Mounting: Wall - Interior/Exterior; Outlet: 1 x type 2 socket
Type - Dimensions - Depth: 180 mm; Height: 322 mm; Rotation U-Axis Correction: 90 deg; Rotation V-Axis Correction: 180 deg; Rotation W-Axis Correction: 0 deg; Width: 249 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM; Voltage: 230 V
Type - Electrical - Loads - Power: 7400 W
Type - Electrical Engineering - Hertz: 50 Hz; Nominal Current: 0.032 A; Phase: 1
Type - Identity Data - Article Description: Single-phase charger 7.4 kW with 1 socket; Article Type: VE 741 S00; Base Family Version: 26.07; Category: EL_POWERCONSUMERCOMMENT; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Single-phase charger 7.4 kW with 1 socket; EMCS Version: 5.0; ETIM Article Class: EC002883; Family Version: 26.07; GLN: 8422447000009; GTIN: 8422447018905; Manufacturer: Dinuy; Manufacturer Art. No.: VE 741 S00; Manufacturer URL: https://emobility.dinuy.com/en/product/889/7u4kw-single-phase-charger-with-1-socket; MEPcontent Class: CHARGING_STATION; Model: VE 741 S00; OmniClass Number: 23.80.30.14; OmniClass Title: Power Distribution; Product Line: Dinuy; Revit Version: 2024; Symbol ID: E00114; Type Name: VE 741 S00; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Mechanical - Weight: 4.8 kg
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Electrical Fixtures; Family Name: E_Charging Station_MEPcontent_Dinuy_VE 741 S00_INT-EN
Type - Visibility - Back Clearance: 0 mm; Front Clearance: 0 mm
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: Dinuy
Pset_BuildingElementProxyCommon - Reference: VE 741 S00
Pset_EnvironmentalImpactIndicators - Reference: VE 741 S00
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 1.74837 m2; Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Volume: 0.0096804 m3
Electrical - Circuiting - Electrical Data: Power - Unbalanced 230 V/1-0 VA
Identity Data - Function Code: E6413; Mark: 6
Other - Bottom Clearance Safe: 600 mm; Family: E_Charging Station_MEPcontent_Dinuy_VE 741 S00_INT-EN; Family and Type: E_Charging Station_MEPcontent_Dinuy_VE 741 S00_INT-EN: VE 741 S00; Left Clearance Safe: 300 mm; Right Clearance Safe: 300 mm; Top Clearance Safe: 300 mm; Type: VE 741 S00; Type Id: 1556425
Phasing - Phase Created: 4. Plan over 10 years
Visibility - Bottom Clearance: 600 mm; Left Clearance: 300 mm; Right Clearance: 300 mm; Service Space: no; Top Clearance: 300 mm

# IfcDistributionPort, Port_1556440
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: CABLE; SystemType: ELECTRICAL
